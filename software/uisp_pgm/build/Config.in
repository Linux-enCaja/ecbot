## software/uisp_pgm/build/Config.in
```kconfig
config BR2_PACKAGE_UISP
	bool "uisp"
	default n
	select BR2_INSTALL_LIBSTDCPP
	help
	  Install the uisp package
```
